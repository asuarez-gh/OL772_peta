SRC_URI += "file://user_2018-02-14-11-06-00.cfg \
            file://user_2018-02-15-14-53-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

